# Keil uVision project Usart.uvproj, settings and files
target Usart (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Usart +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USER_STDPERIPH_DERIVER
  c include: ..\Lib\inc;..\user;..\Lib\startup\arm;..\Lib\cmsis
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_LIB
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c usart.c
  group CORE
    ../Lib/cmsis/: core_cm3.c core_cm3.h
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
